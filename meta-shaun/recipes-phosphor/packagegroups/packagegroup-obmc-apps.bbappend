RDEPENDS:${PN}-bmcweb:append =" \
        webui-vue \
        "